Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Jonas\Documents\Cadfocus\Ostnor\2013\20131122_CAD-objekt_MMIX\ARBETSMAPP\753001_DB\AutoCAD Architecture\753001_DB.ifc
Time: 2013-11-29T17:11:22
Author: - -
Organization: Mora Armatur
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 753001_DB
LongName: 753001_DB
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 753001_DB
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 753001_DB, BUILDINGELEMENTPROXY(1)
In: 753001_DB
Description: Mora MMIX W5 Kitchen/Basin mixer, Wallmounted 150c/c, outlet down, eccentric
